# IAR project rtcs_twrk64f120m.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; MQX_USE_IO_OLD=0; PLATFORM_SDK_ENABLED=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/mqx/source/psp/cortex_m/compiler/iar; ../../../../../../platform/devices/MK64F12/include; ../../../../../../platform/devices/MK64F12/startup; ../../../source/port/phyksz8041; ../../../source/port; ../../../source/apps; ../../../source/if; ../../../source/include; ../../../source/media; ../../../../../../rtos/mqx/config/board/twrk64f120m; ../../../../../../rtos/mqx/config/mcu/MK64F12; ../../../../../../rtos/mqx/mqx/source/psp/cortex_m; ../../../../../../rtos/mqx/mqx/source/psp/cortex_m/cpu; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/tad; ../../../../../../rtos/mqx/mqx_stdlib/source/include; ../../../../../../rtos/mqx/mqx/source/nio; ../../../../../../rtos/mqx/mqx/source/nio/fs; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/mqx/source; ../../../source/nat; ../../../source/os; ../../../source/ppp; ../../../../../../rtos/mqx/nshell/source/include; ../../../source/snmp; ../../../source/tcpip; ../../../../../../examples/twrk64f120m; ../../../../../../platform/devices/MK64F12/startup; ../../../../../../platform/devices/MK64F12/include; ../../../../../../platform; ../../../../../../platform/devices; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/enet; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/drivers/src/uart; ../../../../../../platform/utilities/inc; ../../../../../filesystem/mfs/source/mfs_sdcard/nio_esdhc; ../../../../../../rtos; ../../../../../../platform/osa/inc; ../../../../../../platform/system/inc; ../../../../../filesystem/mfs/source/include; ../../../../../security/wolfssl/source/wolfssl; ../../../../../security/wolfssl/source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../../examples/twrk64f120m; ../../../../../../platform/devices/MK64F12/startup; ../../../../../../platform/devices/MK64F12/include
  postbuild: "../../bat/rtcs_twrk64f120m.bat" "../../../.." "../../../lib/twrk64f120m.iar/debug/rtcs" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; MQX_USE_IO_OLD=0; PLATFORM_SDK_ENABLED=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  postbuild: "../../bat/rtcs_twrk64f120m.bat" "../../../.." "../../../lib/twrk64f120m.iar/release/rtcs" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group RTCS Enet driver
    ../../../source/port/phyksz8041/: fsl_phy_driver.h fsl_phy_driver.c
    ../../../source/port/: fsl_enet_rtcs_adapter.h fsl_enet_rtcs_adapter.c
  group RTCS Source/apps
    ../../../source/apps/: dhcpsrv.c dnscln.c echocln.c echosrv.c ftpc.c ftpc_cmd.c ftpclnt.c ftpsrv.c ftpsrv_cmd.c ftpsrv_cmd_file.c ftpsrv_cmd_transfer.c ftpsrv_msg.c ftpsrv_supp.c ftpsrv_task.c httpsrv.c httpsrv_script.c httpsrv_supp.c httpsrv_task.c httpsrv_ws.c httpsrv_ws_api.c llmnrsrv.c modem.c modem_supp.c rtcs_base64.c rtcs_sha1.c rtcs_smtp.c rtcs_ssl.c rtcs_util.c rtcs_utf8.c sntp.c socknio.c telnetcln.c telnetcln_supp.c telnetcln_task.c telnetio.c telnetsrv.c telnetsrv_supp.c telnetsrv_task.c tftp_supp.c tftpcln.c tftpcln_supp.c tftpcln_task.c tftpsrv.c tftpsrv_supp.c tftpsrv_task.c
  group RTCS Source/if
    ../../../source/if/: arpcmd.c getaddrinfo.c getnameinfo.c ifbootp.c ifdhcp.c ifppp.c ifstat.c iftraps.c iftunnel.c inet.c inet_ntop.c inet_pton.c ipcfg.c ipcfg6.c iwcfg.c ping.c ping6.c rtcs.c rtcs_hosts.c rtcs_if.c rtcscmd.c rtcsdela.c rtcsglob.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sock.c sock_close.c sock_dgram.c sock_options.c sock_select.c sock_stream.c sock_util.c soigmp.c soip.c solink.c
  group RTCS Source/media
    ../../../source/media/: arp.c ip-e.c ipcp.c ipcpfsm.c proxyarp.c
  group RTCS Source/nat
    ../../../source/nat/: alggen.c dnat.c ifdnat.c ifnat.c nat.c nat_apply.c natalg.c natdata.c natevent.c natftp.c nattftp.c sonat.c
  group RTCS Source/os
    ../../../source/os/mqx/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group RTCS Source/ppp
    ../../../source/ppp/: ccp.c chap.c gen16.c genmd5.c lcp.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group RTCS Source/snmp
    ../../../source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group RTCS Source/tcpip
    ../../../source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_reasm.c ip_if.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcpip.c ticker.c timer.c udp.c
  group RTCS Include
    ../../../source/include/: arp.h arp_prv.h arpif.h asn1.h bootp.h ccp.h chap.h checksum.h dhcp.h dhcp6.h dhcp_prv.h dhcpcln6.h dhcpcln6_prv.h dhcpsrv.h dhcpuprv.h dnscln.h dns_prv.h echocln.h fcs16.h ftpc.h ftpsrv.h ftpsrv_msg.h ftpsrv_prv.h httpsrv.h httpsrv_prv.h httpsrv_supp.h httpsrv_ws_prv.h httpsrv_script.h httpsrv_ws.h icmp.h icmp_prv.h iwcfg.h llmnrsrv.h rip_prv.h rtcs_base64.h rtcs_sha1.h rtcs_user_config.h rtcs_utf8.h igmp.h ip.h ip_prv.h ip_if.h ipcfg.h ipcfg_prv.h ip-e.h ipcp.h ipradix.h iptunnel.h lcp.h md5.h nat.h nat_prv.h nat_session.h natvers.h pap.h ppp.h ppp_prv.h pppfsm.h ppphdlc.h rip.h route.h rtcs.h rtcs_sock.h rtcs_ssl.h rtcs_err.h rtcs_stats.h rtcs_if.h rtcs_hosts.h rtcs_assert.h echosrv.h rtcs_in.h rtcs_prv.h rtcs_smtp.h rtcs_util.h rtcs25x.h rtcscfg.h rtcslog.h rtcspcb.h rtcsrtos.h rtcstime.h rtcsvers.h snmp.h snmpcfg.h socket.h tcp.h tcp_prv.h tcpip.h telnet.h telnetcln.h telnetcln_prv.h telnetsrv.h telnetsrv_prv.h tftp_prv.h tftpcln.h tftpcln_prv.h tftpsrv.h tftpsrv_prv.h ticker.h udp.h udp_prv.h icmp6.h icmp6_prv.h ip6.h ip6_if.h ip6_prv.h ip6_trace.h nd6.h mld.h addrinfo.h
  group Shell Commands Source
    ../../../../../../rtos/mqx/nshell/source/rtcs/: sh_arpdisp.c sh_clock.c sh_echo.c sh_echosrv.c sh_enet.c sh_ftpc.c sh_ftpsrv.c sh_gate.c sh_getname.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_llmnrsrv.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_telnetcln.c sh_telnetsrv.c sh_tftpcln.c sh_tftpsrv.c
