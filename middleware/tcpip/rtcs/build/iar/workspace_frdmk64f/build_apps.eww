<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>snmp_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>shell_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>httpsrv_wolfssl_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>httpsrv_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>eth_to_serial_frdmk64f</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>snmp_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>snmp_frdmk64f</project><configuration>int flash release</configuration></member><member><project>shell_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>shell_frdmk64f</project><configuration>int flash release</configuration></member><member><project>httpsrv_wolfssl_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>httpsrv_wolfssl_frdmk64f</project><configuration>int flash release</configuration></member><member><project>httpsrv_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>httpsrv_frdmk64f</project><configuration>int flash release</configuration></member><member><project>eth_to_serial_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>eth_to_serial_frdmk64f</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>snmp_frdmk64f</project><configuration>int flash release</configuration></member><member><project>shell_frdmk64f</project><configuration>int flash release</configuration></member><member><project>httpsrv_wolfssl_frdmk64f</project><configuration>int flash release</configuration></member><member><project>httpsrv_frdmk64f</project><configuration>int flash release</configuration></member><member><project>eth_to_serial_frdmk64f</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\examples\snmp\build\iar\snmp_frdmk64f\snmp_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\shell\build\iar\shell_frdmk64f\shell_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\httpsrv\build\iar\httpsrv_wolfssl_frdmk64f\httpsrv_wolfssl_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\httpsrv\build\iar\httpsrv_frdmk64f\httpsrv_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\eth_to_serial\build\iar\eth_to_serial_frdmk64f\eth_to_serial_frdmk64f.ewp</path></project></workspace>
