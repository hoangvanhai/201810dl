<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>snmp_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>shell_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>httpsrv_wolfssl_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>httpsrv_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>eth_to_serial_twrk65f180m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>snmp_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>snmp_twrk65f180m</project><configuration>int flash release</configuration></member><member><project>shell_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>shell_twrk65f180m</project><configuration>int flash release</configuration></member><member><project>httpsrv_wolfssl_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>httpsrv_wolfssl_twrk65f180m</project><configuration>int flash release</configuration></member><member><project>httpsrv_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>httpsrv_twrk65f180m</project><configuration>int flash release</configuration></member><member><project>eth_to_serial_twrk65f180m</project><configuration>int flash debug</configuration></member><member><project>eth_to_serial_twrk65f180m</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>snmp_twrk65f180m</project><configuration>int flash release</configuration></member><member><project>shell_twrk65f180m</project><configuration>int flash release</configuration></member><member><project>httpsrv_wolfssl_twrk65f180m</project><configuration>int flash release</configuration></member><member><project>httpsrv_twrk65f180m</project><configuration>int flash release</configuration></member><member><project>eth_to_serial_twrk65f180m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\examples\snmp\build\iar\snmp_twrk65f180m\snmp_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\shell\build\iar\shell_twrk65f180m\shell_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\httpsrv\build\iar\httpsrv_wolfssl_twrk65f180m\httpsrv_wolfssl_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\httpsrv\build\iar\httpsrv_twrk65f180m\httpsrv_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\eth_to_serial\build\iar\eth_to_serial_twrk65f180m\eth_to_serial_twrk65f180m.ewp</path></project></workspace>
