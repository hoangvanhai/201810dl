<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\examples\snmp\build\mdk\snmp_twrk64f120m\snmp_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\examples\shell\build\mdk\shell_twrk64f120m\shell_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\examples\httpsrv\build\mdk\httpsrv_wolfssl_twrk64f120m\httpsrv_wolfssl_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\examples\httpsrv\build\mdk\httpsrv_twrk64f120m\httpsrv_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\examples\eth_to_serial\build\mdk\eth_to_serial_twrk64f120m\eth_to_serial_twrk64f120m.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
