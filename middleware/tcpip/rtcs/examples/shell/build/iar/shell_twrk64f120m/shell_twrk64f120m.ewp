# IAR project shell_twrk64f120m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; MQX_USE_IO_OLD=0; PLATFORM_SDK_ENABLED=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MK64F12; ../../../../../../../../rtos/mqx/config/board/twrk64f120m; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../examples/twrk64f120m; ../../../../../../../../examples/twrk64f120m; ../../../../../../../../platform/devices/MK64F12/startup; ../../../../../../../../platform/devices/MK64F12/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/enet; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../../../filesystem/mfs/source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../../../filesystem/mfs/source/include; ../../../../../../../security/wolfssl/source/wolfssl; ../../../../../../../security/wolfssl/source; ../../../../../lib/twrk64f120m.iar/debug/rtcs; ../../../../../../../filesystem/mfs/lib/twrk64f120m.iar/debug/mfs; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/nshell; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/config; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/mqx; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/mqx_stdlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../../../../rtos/mqx/config/mcu/MK64F12; ../../../../../../../../rtos/mqx/config/board/twrk64f120m; ../../../../../../../../examples/twrk64f120m; ../../../../../../../../platform/devices/MK64F12/startup; ../../../../../../../../platform/devices/MK64F12/include
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: shell.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x1
  ILINK.IlinkIcfFile: ../../../../../../../../platform/devices/MK64F12/linker/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/K64F12/debug/libksdk_platform_mqx.a; ../../../../../lib/twrk64f120m.iar/debug/rtcs/lib_rtcs.a; ../../../../../../../filesystem/mfs/lib/twrk64f120m.iar/debug/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/debug/mqx_stdlib/lib_mqx_stdlib.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12=1; FSL_RTOS_MQX=1; MQX_USE_IO_OLD=0; PLATFORM_SDK_ENABLED=1; NDEBUG=1
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MK64F12; ../../../../../../../../rtos/mqx/config/board/twrk64f120m; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../examples/twrk64f120m; ../../../../../../../../examples/twrk64f120m; ../../../../../../../../platform/devices/MK64F12/startup; ../../../../../../../../platform/devices/MK64F12/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/enet; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../../../filesystem/mfs/source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../../../filesystem/mfs/source/include; ../../../../../../../security/wolfssl/source/wolfssl; ../../../../../../../security/wolfssl/source; ../../../../../lib/twrk64f120m.iar/release/rtcs; ../../../../../../../filesystem/mfs/lib/twrk64f120m.iar/release/mfs; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/nshell; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/config; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/mqx; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/mqx_stdlib
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/K64F12/release/libksdk_platform_mqx.a; ../../../../../lib/twrk64f120m.iar/release/rtcs/lib_rtcs.a; ../../../../../../../filesystem/mfs/lib/twrk64f120m.iar/release/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/twrk64f120m.iar/release/mqx_stdlib/lib_mqx_stdlib.a
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MK64F12/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/twrk64f120m/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h lite_config.h verif_enabled_config.h
  group Source
    ../../../: app_mqx.c app_mqx.h app_rtos.h demo.c main.h config.h demo_cmd.c _README.txt
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../common/: hardware_init.c
  group KSDK Files
    ../../../../../../../../examples/twrk64f120m/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
