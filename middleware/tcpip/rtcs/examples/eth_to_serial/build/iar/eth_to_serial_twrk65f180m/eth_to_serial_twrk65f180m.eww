<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_twrk65f180m</project><configuration>debug</configuration></member><member><project>rtcs_twrk65f180m</project><configuration>debug</configuration></member><member><project>nshell_twrk65f180m</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrk65f180m</project><configuration>debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>eth_to_serial_twrk65f180m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_twrk65f180m</project><configuration>release</configuration></member><member><project>rtcs_twrk65f180m</project><configuration>release</configuration></member><member><project>nshell_twrk65f180m</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrk65f180m</project><configuration>release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>eth_to_serial_twrk65f180m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx\build\iar\mqx_twrk65f180m\mqx_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\rtcs_twrk65f180m\rtcs_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\nshell\build\iar\nshell_twrk65f180m\nshell_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx_stdlib\build\iar\mqx_stdlib_twrk65f180m\mqx_stdlib_twrk65f180m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\lib\ksdk_mqx_lib\iar\K65F18\ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$\eth_to_serial_twrk65f180m.ewp</path></project></workspace>
