# Keil uVision project mfs_usbkw24d512.uvprojx, settings and files
target debug (ARM-ADS)
  device: MKW24D512VHA5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: lib_mfs.lib (library)
  AfterMake: ../../bat/mfs_usbkw24d512.bat ../../.. ../../../lib/usbkw24d512.mdk/debug/mfs mdk
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKW24D512VHA5=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, _DEBUG=1
  c misc: -J../../../../../../rtos/mqx/mqx/source/psp/cortex_m/compiler/rv_mdk 
-J../../../source/include 
-J../../../../../../rtos/mqx/mqx/source/psp/cortex_m 
-J../../../../../../rtos/mqx/mqx/source/psp/cortex_m/cpu 
-J../../../../../../rtos/mqx/mqx/source/include 
-J../../../../../../rtos/mqx/config/common 
-J../../../../../../rtos/mqx/mqx/source/tad 
-J../../../../../../rtos/mqx/mqx_stdlib/source/include 
-J../../../../../../rtos/mqx/mqx/source/nio 
-J../../../../../../rtos/mqx/mqx/source/nio/fs 
-J../../../../../../rtos/mqx/mqx/source/bsp 
-J../../../../../../rtos/mqx/config/board/usbkw24d512 
-J../../../../../../rtos/mqx/config/mcu/MKW24D5 
-J../../../../../../rtos/mqx/nshell/source/include 
-J../../../../../../examples/usbkw24d512 
-J../../../../../../platform/devices/MKW24D5/startup 
-J../../../../../../platform/devices/MKW24D5/include 
-J../../../../../../platform 
-J../../../../../../platform/devices 
-J../../../../../../platform/CMSIS/Include 
-J../../../../../../platform/hal/inc 
-J../../../../../../platform/drivers/inc 
-J../../../../../../platform/drivers/src/mpu 
-J../../../../../../platform/drivers/src/uart 
-J../../../../../../platform/utilities/inc 
-J../../../source/mfs_sdcard/nio_esdhc 
-J../../../../../../rtos 
-J../../../../../../platform/osa/inc 
-J../../../../../../platform/system/inc 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../rtos/mqx/mqx/source/psp/cortex_m/compiler/rv_mdk;../../../source/include;../../../../../../rtos/mqx/mqx/source/psp/cortex_m;../../../../../../rtos/mqx/mqx/source/psp/cortex_m/cpu;../../../../../../rtos/mqx/mqx/source/include;../../../../../../rtos/mqx/config/common;../../../../../../rtos/mqx/mqx/source/tad;../../../../../../rtos/mqx/mqx_stdlib/source/include;../../../../../../rtos/mqx/mqx/source/nio;../../../../../../rtos/mqx/mqx/source/nio/fs;../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../rtos/mqx/config/board/usbkw24d512;../../../../../../rtos/mqx/config/mcu/MKW24D5;../../../../../../rtos/mqx/nshell/source/include;../../../../../../examples/usbkw24d512;../../../../../../platform/devices/MKW24D5/startup;../../../../../../platform/devices/MKW24D5/include;../../../../../../platform;../../../../../../platform/devices;../../../../../../platform/CMSIS/Include;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/drivers/src/uart;../../../../../../platform/utilities/inc;../../../source/mfs_sdcard/nio_esdhc;../../../../../../rtos;../../../../../../platform/osa/inc;../../../../../../platform/system/inc
  asm misc: --cpreproc_opts '-DCPU_MKW24D512VHA5=1,-DFSL_RTOS_MQX=1,-DPLATFORM_SDK_ENABLED=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../examples/usbkw24d512;../../../../../../platform/devices/MKW24D5/startup;../../../../../../platform/devices/MKW24D5/include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\mk24d512.mdk\mqx\intflash.scf
  group MFS Include
    ../../../source/include/: mfs_cnfg.h mfs_prv.h mfs_rev.h sh_mfs.h mfs.h part_mgr.h
  group Shell Commands Source
    ../../../../../../rtos/mqx/nshell/source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
    ../../../../../../rtos/mqx/nshell/source/include/: sh_mfs.h
  group MFS Source
    ../../../source/generic/: dir_read.c mfs_attribute.c mfs_cache.c mfs_cluster.c mfs_delete.c mfs_dir_entry.c mfs_dir_chain.c mfs_directory.c mfs_fat.c mfs_find.c mfs_format.c mfs_flush.c mfs_globals.c mfs_handle.c mfs_chain.c mfs_ioctl.c mfs_lfn.c mfs_misc.c mfs_mount.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_unicode.c mfs_valdev.c mfs_write.c part_mgr.c mfs_nio.c
target release (ARM-ADS)
  device: MKW24D512VHA5 Freescale
  cpu: CPUTYPE("Cortex-M4")
  output: lib_mfs.lib (library)
  AfterMake: ../../bat/mfs_usbkw24d512.bat ../../.. ../../../lib/usbkw24d512.mdk/release/mfs mdk
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKW24D512VHA5=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DCPU_MKW24D512VHA5=1,-DFSL_RTOS_MQX=1,-DPLATFORM_SDK_ENABLED=1,-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\mk24d512.mdk\mqx\intflash.scf
