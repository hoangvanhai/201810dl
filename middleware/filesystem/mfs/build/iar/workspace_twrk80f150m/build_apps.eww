<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>usbdisk_twrk80f150m</project><configuration>int flash debug</configuration></member><member><project>ramdisk_twrk80f150m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>usbdisk_twrk80f150m</project><configuration>int flash debug</configuration></member><member><project>usbdisk_twrk80f150m</project><configuration>int flash release</configuration></member><member><project>ramdisk_twrk80f150m</project><configuration>int flash debug</configuration></member><member><project>ramdisk_twrk80f150m</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>usbdisk_twrk80f150m</project><configuration>int flash release</configuration></member><member><project>ramdisk_twrk80f150m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\examples\usbdisk\build\iar\usbdisk_twrk80f150m\usbdisk_twrk80f150m.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\ramdisk\build\iar\ramdisk_twrk80f150m\ramdisk_twrk80f150m.ewp</path></project></workspace>
