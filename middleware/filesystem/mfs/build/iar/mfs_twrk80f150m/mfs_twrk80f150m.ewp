# IAR project mfs_twrk80f150m.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: CPU_MK80FN256VDC15=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../../../rtos/mqx/mqx/source/psp/cortex_m/compiler/iar; ../../../source/include; ../../../source/mfs_sdcard/nio_sdcard/sdcard_esdhc; ../../../source/mfs_sdcard/nio_sdcard; ../../../source/mfs_sdcard/nio_esdhc; ../../../../../../usb/usb_core/include; ../../../../../../usb/usb_core/host/include; ../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../usb/adapter/sources; ../../../../../../usb/adapter/sources/sdk; ../../../../../../usb/usb_core/host/include/MK80F25615; ../../../../../../rtos/mqx/mqx/source/psp/cortex_m; ../../../../../../rtos/mqx/mqx/source/psp/cortex_m/cpu; ../../../../../../rtos/mqx/mqx/source/include; ../../../../../../rtos/mqx/config/common; ../../../../../../rtos/mqx/mqx/source/tad; ../../../../../../rtos/mqx/mqx_stdlib/source/include; ../../../../../../rtos/mqx/mqx/source/nio; ../../../../../../rtos/mqx/mqx/source/nio/fs; ../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../rtos/mqx/config/board/twrk80f150m; ../../../../../../rtos/mqx/config/mcu/MK80F25615; ../../../../../../examples/twrk80f150m; ../../../../../../platform/devices/MK80F25615/include; ../../../../../../platform/devices/MK80F25615/startup; ../../../../../../rtos/mqx/nshell/source/include; ../../../../../../examples/twrk80f150m; ../../../../../../platform/devices/MK80F25615/startup; ../../../../../../platform/devices/MK80F25615/include; ../../../../../../platform; ../../../../../../platform/devices; ../../../../../../platform/CMSIS/Include; ../../../../../../platform/hal/inc; ../../../../../../platform/drivers/inc; ../../../../../../platform/drivers/src/mpu; ../../../../../../platform/drivers/src/uart; ../../../../../../platform/utilities/inc; ../../../source/mfs_sdcard/nio_esdhc; ../../../../../../rtos; ../../../../../../platform/osa/inc; ../../../../../../platform/system/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../../examples/twrk80f150m; ../../../../../../platform/devices/MK80F25615/startup; ../../../../../../platform/devices/MK80F25615/include
  postbuild: "../../bat/mfs_twrk80f150m.bat" "../../.." "../../../lib/twrk80f150m.iar/debug/mfs" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK80FN256VDC15=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  postbuild: "../../bat/mfs_twrk80f150m.bat" "../../.." "../../../lib/twrk80f150m.iar/release/mfs" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group MFS Include
    ../../../source/include/: mfs_cnfg.h mfs_prv.h mfs_rev.h sh_mfs.h mfs.h part_mgr.h
  group MFS-SDCard
    ../../../source/mfs_sdcard/nio_esdhc/: esdhc_prv.h esdhc.h esdhc.c
    ../../../source/mfs_sdcard/nio_sdcard/sdcard_esdhc/: sdcard_esdhc.h sdcard_esdhc.c
    ../../../source/mfs_sdcard/nio_sdcard/: sdcard_prv.h sdcard.h sdcard.c
  group MFS-USB layer
    ../../../source/mfs_usb/: mfs_usb.c mfs_usb.h
  group Shell Commands Source
    ../../../../../../rtos/mqx/nshell/source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
    ../../../../../../rtos/mqx/nshell/source/include/: sh_mfs.h
  group MFS Source
    ../../../source/generic/: dir_read.c mfs_attribute.c mfs_cache.c mfs_cluster.c mfs_delete.c mfs_dir_entry.c mfs_dir_chain.c mfs_directory.c mfs_fat.c mfs_find.c mfs_format.c mfs_flush.c mfs_globals.c mfs_handle.c mfs_chain.c mfs_ioctl.c mfs_lfn.c mfs_misc.c mfs_mount.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_unicode.c mfs_valdev.c mfs_write.c part_mgr.c mfs_nio.c
