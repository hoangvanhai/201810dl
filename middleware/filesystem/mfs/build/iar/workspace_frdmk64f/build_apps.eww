<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>usbdisk_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>sdbench_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>sdcard_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>ramdisk_frdmk64f</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>usbdisk_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>usbdisk_frdmk64f</project><configuration>int flash release</configuration></member><member><project>sdbench_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>sdbench_frdmk64f</project><configuration>int flash release</configuration></member><member><project>sdcard_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>sdcard_frdmk64f</project><configuration>int flash release</configuration></member><member><project>ramdisk_frdmk64f</project><configuration>int flash debug</configuration></member><member><project>ramdisk_frdmk64f</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>usbdisk_frdmk64f</project><configuration>int flash release</configuration></member><member><project>sdbench_frdmk64f</project><configuration>int flash release</configuration></member><member><project>sdcard_frdmk64f</project><configuration>int flash release</configuration></member><member><project>ramdisk_frdmk64f</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\examples\usbdisk\build\iar\usbdisk_frdmk64f\usbdisk_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\sdbench\build\iar\sdbench_frdmk64f\sdbench_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\sdcard\build\iar\sdcard_frdmk64f\sdcard_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\ramdisk\build\iar\ramdisk_frdmk64f\ramdisk_frdmk64f.ewp</path></project></workspace>
