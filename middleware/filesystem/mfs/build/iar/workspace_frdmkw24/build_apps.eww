<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>ramdisk_frdmkw24</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>ramdisk_frdmkw24</project><configuration>int flash debug</configuration></member><member><project>ramdisk_frdmkw24</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>ramdisk_frdmkw24</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\examples\ramdisk\build\iar\ramdisk_frdmkw24\ramdisk_frdmkw24.ewp</path></project></workspace>
