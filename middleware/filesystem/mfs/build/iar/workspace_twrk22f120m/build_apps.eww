<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>int flash debug</name><member><project>usbdisk_twrk22f120m</project><configuration>int flash debug</configuration></member><member><project>ramdisk_twrk22f120m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>usbdisk_twrk22f120m</project><configuration>int flash debug</configuration></member><member><project>usbdisk_twrk22f120m</project><configuration>int flash release</configuration></member><member><project>ramdisk_twrk22f120m</project><configuration>int flash debug</configuration></member><member><project>ramdisk_twrk22f120m</project><configuration>int flash release</configuration></member></batchDefinition><batchDefinition><name>int flash release</name><member><project>usbdisk_twrk22f120m</project><configuration>int flash release</configuration></member><member><project>ramdisk_twrk22f120m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\examples\usbdisk\build\iar\usbdisk_twrk22f120m\usbdisk_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\examples\ramdisk\build\iar\ramdisk_twrk22f120m\ramdisk_twrk22f120m.ewp</path></project></workspace>
