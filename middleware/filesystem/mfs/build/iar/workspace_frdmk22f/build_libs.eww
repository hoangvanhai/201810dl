<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mfs_frdmk22f</project><configuration>debug</configuration></member></batchDefinition><batchDefinition><name>all</name><member><project>mfs_frdmk22f</project><configuration>debug</configuration></member><member><project>mfs_frdmk22f</project><configuration>release</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mfs_frdmk22f</project><configuration>release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\mfs_frdmk22f\mfs_frdmk22f.ewp</path></project></workspace>
