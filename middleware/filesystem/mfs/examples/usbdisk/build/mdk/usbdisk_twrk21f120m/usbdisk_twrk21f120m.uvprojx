# Keil uVision project usbdisk_twrk21f120m.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MK21FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: usbdisk.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK21FN1M0AVMC12=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, _DEBUG=1
  c misc: -J../../../../../../../../rtos/mqx/config/mcu/MK21FA12 
-J../../../../../../../../rtos/mqx/config/board/twrk21f120m 
-J../../../../../../../../rtos/mqx/config/common 
-J../../.. 
-J../../../../../../../../rtos/mqx/mqx/source/include 
-J../../../../../../../../rtos/mqx/mqx/source/bsp 
-J../../../../../../../../platform/utilities 
-J../../../../../../../../examples/twrk21f120m 
-J../../../../../../../../platform/devices/MK21FA12/startup 
-J../../../../../../../../examples/twrk21f120m 
-J../../../../../../../../platform/devices/MK21FA12/startup 
-J../../../../../../../../platform/devices/MK21FA12/include 
-J../../../../../../../../platform 
-J../../../../../../../../platform/devices 
-J../../../../../../../../platform/CMSIS/Include 
-J../../../../../../../../platform/hal/inc 
-J../../../../../../../../platform/drivers/inc 
-J../../../../../../../../platform/drivers/src/mpu 
-J../../../../../../../../platform/drivers/src/uart 
-J../../../../../../../../platform/utilities/inc 
-J../../../../../source/mfs_sdcard/nio_esdhc 
-J../../../../../../../../rtos 
-J../../../../../../../../platform/osa/inc 
-J../../../../../../../../platform/system/inc 
-J../../../../../lib/twrk21f120m.mdk/debug/mfs 
-J../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/nshell 
-J../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/config 
-J../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/mqx 
-J../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/mqx_stdlib 
-J../../../../../../../../usb/usb_core/include 
-J../../../../../../../../usb/usb_core/host/include 
-J../../../../../../../../usb/usb_core/host/include/MK21FA12 
-J../../../../../../../../usb/usb_core/host/sources/classes/msd 
-J../../../../../../../../usb/usb_core/host/sources/classes/hub 
-J../../../../../../../../usb/adapter/sources 
-J../../../../../../../../usb/adapter/sources/sdk 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../../../rtos/mqx/config/mcu/MK21FA12;../../../../../../../../rtos/mqx/config/board/twrk21f120m;../../../../../../../../rtos/mqx/config/common;../../..;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../platform/utilities;../../../../../../../../examples/twrk21f120m;../../../../../../../../platform/devices/MK21FA12/startup;../../../../../../../../examples/twrk21f120m;../../../../../../../../platform/devices/MK21FA12/startup;../../../../../../../../platform/devices/MK21FA12/include;../../../../../../../../platform;../../../../../../../../platform/devices;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/utilities/inc;../../../../../source/mfs_sdcard/nio_esdhc;../../../../../../../../rtos;../../../../../../../../platform/osa/inc;../../../../../../../../platform/system/inc;../../../../../lib/twrk21f120m.mdk/debug/mfs;../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/nshell;../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/config;../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/mqx;../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/mqx_stdlib;../../../../../../../../usb/usb_core/include;../../../../../../../../usb/usb_core/host/include;../../../../../../../../usb/usb_core/host/include/MK21FA12;../../../../../../../../usb/usb_core/host/sources/classes/msd;../../../../../../../../usb/usb_core/host/sources/classes/hub;../../../../../../../../usb/adapter/sources;../../../../../../../../usb/adapter/sources/sdk
  asm misc: --cpreproc_opts '-DCPU_MK21FN1M0AVMC12=1,-DFSL_RTOS_MQX=1,-DPLATFORM_SDK_ENABLED=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../../../rtos/mqx/config/mcu/MK21FA12;../../../../../../../../rtos/mqx/config/board/twrk21f120m;../../../../../../../../examples/twrk21f120m;../../../../../../../../platform/devices/MK21FA12/startup;../../../../../../../../platform/devices/MK21FA12/include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../../../../platform/devices/MK21FA12/linker/arm/MK21FN1M0Axxx12_flash.scf
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/K21FA12/debug/libksdk_platform_mqx.lib 
../../../../../lib/twrk21f120m.mdk/debug/mfs/lib_mfs.lib 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/nshell/lib_nshell.lib 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../usb/usb_core/host/lib/mqx/mdk/MK21FA12/debug/libusbh_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--autoat 
--any_placement=first_fit 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MK21FA12/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/twrk21f120m/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h lite_config.h verif_enabled_config.h
  group Sources
    ../../../: main.c usb_file.c Shell_Task.c usb_file.h hardware_init.c
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group Debug Console
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.h print_scan.c
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group KSDK Files
    ../../../../../../../../examples/twrk21f120m/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
target int flash release (ARM-ADS)
  device: MK21FN1M0xxx12 Freescale Semiconductor
  cpu: CPUTYPE("Cortex-M4.fp")
  output: usbdisk.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK21FN1M0AVMC12=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, NDEBUG=1
  c misc: -J../../../../../../../../rtos/mqx/config/mcu/MK21FA12 
-J../../../../../../../../rtos/mqx/config/board/twrk21f120m 
-J../../../../../../../../rtos/mqx/config/common 
-J../../.. 
-J../../../../../../../../rtos/mqx/mqx/source/include 
-J../../../../../../../../rtos/mqx/mqx/source/bsp 
-J../../../../../../../../platform/utilities 
-J../../../../../../../../examples/twrk21f120m 
-J../../../../../../../../platform/devices/MK21FA12/startup 
-J../../../../../../../../examples/twrk21f120m 
-J../../../../../../../../platform/devices/MK21FA12/startup 
-J../../../../../../../../platform/devices/MK21FA12/include 
-J../../../../../../../../platform 
-J../../../../../../../../platform/devices 
-J../../../../../../../../platform/CMSIS/Include 
-J../../../../../../../../platform/hal/inc 
-J../../../../../../../../platform/drivers/inc 
-J../../../../../../../../platform/drivers/src/mpu 
-J../../../../../../../../platform/drivers/src/uart 
-J../../../../../../../../platform/utilities/inc 
-J../../../../../source/mfs_sdcard/nio_esdhc 
-J../../../../../../../../rtos 
-J../../../../../../../../platform/osa/inc 
-J../../../../../../../../platform/system/inc 
-J../../../../../lib/twrk21f120m.mdk/release/mfs 
-J../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/nshell 
-J../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/config 
-J../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/mqx 
-J../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/mqx_stdlib 
-J../../../../../../../../usb/usb_core/include 
-J../../../../../../../../usb/usb_core/host/include 
-J../../../../../../../../usb/usb_core/host/include/MK21FA12 
-J../../../../../../../../usb/usb_core/host/sources/classes/msd 
-J../../../../../../../../usb/usb_core/host/sources/classes/hub 
-J../../../../../../../../usb/adapter/sources 
-J../../../../../../../../usb/adapter/sources/sdk 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../../../rtos/mqx/config/mcu/MK21FA12;../../../../../../../../rtos/mqx/config/board/twrk21f120m;../../../../../../../../rtos/mqx/config/common;../../..;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../platform/utilities;../../../../../../../../examples/twrk21f120m;../../../../../../../../platform/devices/MK21FA12/startup;../../../../../../../../examples/twrk21f120m;../../../../../../../../platform/devices/MK21FA12/startup;../../../../../../../../platform/devices/MK21FA12/include;../../../../../../../../platform;../../../../../../../../platform/devices;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/utilities/inc;../../../../../source/mfs_sdcard/nio_esdhc;../../../../../../../../rtos;../../../../../../../../platform/osa/inc;../../../../../../../../platform/system/inc;../../../../../lib/twrk21f120m.mdk/release/mfs;../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/nshell;../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/config;../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/mqx;../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/mqx_stdlib;../../../../../../../../usb/usb_core/include;../../../../../../../../usb/usb_core/host/include;../../../../../../../../usb/usb_core/host/include/MK21FA12;../../../../../../../../usb/usb_core/host/sources/classes/msd;../../../../../../../../usb/usb_core/host/sources/classes/hub;../../../../../../../../usb/adapter/sources;../../../../../../../../usb/adapter/sources/sdk
  asm misc: --cpreproc_opts '-DCPU_MK21FN1M0AVMC12=1,-DFSL_RTOS_MQX=1,-DPLATFORM_SDK_ENABLED=1,-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/K21FA12/release/libksdk_platform_mqx.lib 
../../../../../lib/twrk21f120m.mdk/release/mfs/lib_mfs.lib 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/nshell/lib_nshell.lib 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../usb/usb_core/host/lib/mqx/mdk/MK21FA12/release/libusbh_mqx.lib 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/twrk21f120m.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--autoat 
--any_placement=first_fit 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
