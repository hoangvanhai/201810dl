# IAR project usbdisk_twrk80f150m.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK80FN256VDC15=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MK80F25615; ../../../../../../../../rtos/mqx/config/board/twrk80f150m; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../platform/utilities; ../../../../../../../../examples/twrk80f150m; ../../../../../../../../platform/devices/MK80F25615/startup; ../../../../../../../../examples/twrk80f150m; ../../../../../../../../platform/devices/MK80F25615/startup; ../../../../../../../../platform/devices/MK80F25615/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../lib/twrk80f150m.iar/debug/mfs; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/debug/nshell; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/debug/config; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/debug/mqx; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/debug/mqx_stdlib; ../../../../../../../../usb/usb_core/include; ../../../../../../../../usb/usb_core/host/include; ../../../../../../../../usb/usb_core/host/include/MK80F25615; ../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../usb/adapter/sources; ../../../../../../../../usb/adapter/sources/sdk
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../../../../rtos/mqx/config/mcu/MK80F25615; ../../../../../../../../rtos/mqx/config/board/twrk80f150m; ../../../../../../../../examples/twrk80f150m; ../../../../../../../../platform/devices/MK80F25615/startup; ../../../../../../../../platform/devices/MK80F25615/include
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: usbdisk.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x1
  ILINK.IlinkIcfFile: ../../../../../../../../platform/devices/MK80F25615/linker/iar/MK80FN256xxx15_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/K80F25615/debug/libksdk_platform_mqx.a; ../../../../../lib/twrk80f150m.iar/debug/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/debug/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/debug/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/debug/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../../../usb/usb_core/host/lib/mqx/iar/MK80F25615/debug/libusbh_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK80FN256VDC15=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; NDEBUG=1
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MK80F25615; ../../../../../../../../rtos/mqx/config/board/twrk80f150m; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../platform/utilities; ../../../../../../../../examples/twrk80f150m; ../../../../../../../../platform/devices/MK80F25615/startup; ../../../../../../../../examples/twrk80f150m; ../../../../../../../../platform/devices/MK80F25615/startup; ../../../../../../../../platform/devices/MK80F25615/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../lib/twrk80f150m.iar/release/mfs; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/release/nshell; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/release/config; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/release/mqx; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/release/mqx_stdlib; ../../../../../../../../usb/usb_core/include; ../../../../../../../../usb/usb_core/host/include; ../../../../../../../../usb/usb_core/host/include/MK80F25615; ../../../../../../../../usb/usb_core/host/sources/classes/msd; ../../../../../../../../usb/usb_core/host/sources/classes/hub; ../../../../../../../../usb/adapter/sources; ../../../../../../../../usb/adapter/sources/sdk
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/K80F25615/release/libksdk_platform_mqx.a; ../../../../../lib/twrk80f150m.iar/release/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/release/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/release/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/twrk80f150m.iar/release/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../../../../usb/usb_core/host/lib/mqx/iar/MK80F25615/release/libusbh_mqx.a
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MK80F25615/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/twrk80f150m/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h lite_config.h verif_enabled_config.h
  group Sources
    ../../../: main.c usb_file.c Shell_Task.c usb_file.h hardware_init.c
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group Debug Console
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.h print_scan.c
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group KSDK Files
    ../../../../../../../../examples/twrk80f150m/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
