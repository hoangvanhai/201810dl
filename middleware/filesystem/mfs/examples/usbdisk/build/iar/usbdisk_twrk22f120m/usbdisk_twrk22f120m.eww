<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_twrk22f120m</project><configuration>debug</configuration></member><member><project>mfs_twrk22f120m</project><configuration>debug</configuration></member><member><project>nshell_twrk22f120m</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrk22f120m</project><configuration>debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>usbh_sdk_mqx_lib</project><configuration>debug</configuration></member><member><project>usbdisk_twrk22f120m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_twrk22f120m</project><configuration>release</configuration></member><member><project>mfs_twrk22f120m</project><configuration>release</configuration></member><member><project>nshell_twrk22f120m</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrk22f120m</project><configuration>release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>usbh_sdk_mqx_lib</project><configuration>release</configuration></member><member><project>usbdisk_twrk22f120m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx\build\iar\mqx_twrk22f120m\mqx_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_twrk22f120m\mfs_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\nshell\build\iar\nshell_twrk22f120m\nshell_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx_stdlib\build\iar\mqx_stdlib_twrk22f120m\mqx_stdlib_twrk22f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\lib\ksdk_mqx_lib\iar\K22F51212\ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\usb\usb_core\host\lib\mqx\iar\MK22F51212\usbh_sdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$\usbdisk_twrk22f120m.ewp</path></project></workspace>
