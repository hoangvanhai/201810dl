# IAR project ramdisk_twrkw24d512.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW24D512xxx5 Freescale MKW24D512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MKW24D512VHA5=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MKW24D5; ../../../../../../../../rtos/mqx/config/board/twrkw24d512; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../platform/utilities; ../../../../../../../../examples/twrkw24d512; ../../../../../../../../platform/devices/MKW24D5/startup; ../../../../../../../../examples/twrkw24d512; ../../../../../../../../platform/devices/MKW24D5/startup; ../../../../../../../../platform/devices/MKW24D5/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../lib/twrkw24d512.iar/debug/mfs; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/debug/nshell; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/debug/config; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/debug/mqx; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/debug/mqx_stdlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../../../../rtos/mqx/config/mcu/MKW24D5; ../../../../../../../../rtos/mqx/config/board/twrkw24d512; ../../../../../../../../examples/twrkw24d512; ../../../../../../../../platform/devices/MKW24D5/startup; ../../../../../../../../platform/devices/MKW24D5/include
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: ramdisk.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x1
  ILINK.IlinkIcfFile: ../../../../../../../../platform/devices/MKW24D5/linker/iar/MKW24D512xxx5_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/KW24D5/debug/libksdk_platform_mqx.a; ../../../../../lib/twrkw24d512.iar/debug/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/debug/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/debug/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/debug/mqx_stdlib/lib_mqx_stdlib.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKW24D512VHA5=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; NDEBUG=1
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MKW24D5; ../../../../../../../../rtos/mqx/config/board/twrkw24d512; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../platform/utilities; ../../../../../../../../examples/twrkw24d512; ../../../../../../../../platform/devices/MKW24D5/startup; ../../../../../../../../examples/twrkw24d512; ../../../../../../../../platform/devices/MKW24D5/startup; ../../../../../../../../platform/devices/MKW24D5/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../lib/twrkw24d512.iar/release/mfs; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/release/nshell; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/release/config; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/release/mqx; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/release/mqx_stdlib
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/KW24D5/release/libksdk_platform_mqx.a; ../../../../../lib/twrkw24d512.iar/release/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/release/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/release/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/twrkw24d512.iar/release/mqx_stdlib/lib_mqx_stdlib.a
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MKW24D5/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/twrkw24d512/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h lite_config.h verif_enabled_config.h
  group Sources
    ../../../: Shell_Task.c Tasks.c
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group Debug Console
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.h print_scan.c
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group KSDK Files
    ../../../../../../../../examples/twrkw24d512/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
