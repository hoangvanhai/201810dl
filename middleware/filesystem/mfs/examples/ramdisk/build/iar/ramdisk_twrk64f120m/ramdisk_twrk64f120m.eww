<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_twrk64f120m</project><configuration>debug</configuration></member><member><project>mfs_twrk64f120m</project><configuration>debug</configuration></member><member><project>nshell_twrk64f120m</project><configuration>debug</configuration></member><member><project>mqx_stdlib_twrk64f120m</project><configuration>debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>ramdisk_twrk64f120m</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_twrk64f120m</project><configuration>release</configuration></member><member><project>mfs_twrk64f120m</project><configuration>release</configuration></member><member><project>nshell_twrk64f120m</project><configuration>release</configuration></member><member><project>mqx_stdlib_twrk64f120m</project><configuration>release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>ramdisk_twrk64f120m</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx\build\iar\mqx_twrk64f120m\mqx_twrk64f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_twrk64f120m\mfs_twrk64f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\nshell\build\iar\nshell_twrk64f120m\nshell_twrk64f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx_stdlib\build\iar\mqx_stdlib_twrk64f120m\mqx_stdlib_twrk64f120m.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\lib\ksdk_mqx_lib\iar\K64F12\ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$\ramdisk_twrk64f120m.ewp</path></project></workspace>
