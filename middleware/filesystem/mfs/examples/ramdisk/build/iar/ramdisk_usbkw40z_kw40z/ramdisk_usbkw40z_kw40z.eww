<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_usbkw40z_kw40z</project><configuration>debug</configuration></member><member><project>mfs_usbkw40z_kw40z</project><configuration>debug</configuration></member><member><project>nshell_usbkw40z_kw40z</project><configuration>debug</configuration></member><member><project>mqx_stdlib_usbkw40z_kw40z</project><configuration>debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>ramdisk_usbkw40z_kw40z</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_usbkw40z_kw40z</project><configuration>release</configuration></member><member><project>mfs_usbkw40z_kw40z</project><configuration>release</configuration></member><member><project>nshell_usbkw40z_kw40z</project><configuration>release</configuration></member><member><project>mqx_stdlib_usbkw40z_kw40z</project><configuration>release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>ramdisk_usbkw40z_kw40z</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx\build\iar\mqx_usbkw40z_kw40z\mqx_usbkw40z_kw40z.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_usbkw40z_kw40z\mfs_usbkw40z_kw40z.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\nshell\build\iar\nshell_usbkw40z_kw40z\nshell_usbkw40z_kw40z.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx_stdlib\build\iar\mqx_stdlib_usbkw40z_kw40z\mqx_stdlib_usbkw40z_kw40z.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\lib\ksdk_mqx_lib\iar\KW40Z4\ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$\ramdisk_usbkw40z_kw40z.ewp</path></project></workspace>
