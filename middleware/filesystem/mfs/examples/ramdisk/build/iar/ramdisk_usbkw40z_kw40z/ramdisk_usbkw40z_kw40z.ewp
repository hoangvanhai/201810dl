# IAR project ramdisk_usbkw40z_kw40z.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW40Z160xxx4 Freescale MKW40Z160xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MKW40Z160VHT4=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MKW40Z4; ../../../../../../../../rtos/mqx/config/board/usbkw40z_kw40z; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../platform/utilities; ../../../../../../../../examples/usbkw40z_kw40z; ../../../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../../../examples/usbkw40z_kw40z; ../../../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../../../platform/devices/MKW40Z4/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../lib/usbkw40z_kw40z.iar/debug/mfs; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/nshell; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/config; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/mqx; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/mqx_stdlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../../../../rtos/mqx/config/mcu/MKW40Z4; ../../../../../../../../rtos/mqx/config/board/usbkw40z_kw40z; ../../../../../../../../examples/usbkw40z_kw40z; ../../../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../../../platform/devices/MKW40Z4/include
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: ramdisk.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x1
  ILINK.IlinkIcfFile: ../../../../../../../../platform/devices/MKW40Z4/linker/iar/MKW40Z160xxx4_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/KW40Z4/debug/libksdk_platform_mqx.a; ../../../../../lib/usbkw40z_kw40z.iar/debug/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/debug/mqx_stdlib/lib_mqx_stdlib.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKW40Z160VHT4=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; NDEBUG=1
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MKW40Z4; ../../../../../../../../rtos/mqx/config/board/usbkw40z_kw40z; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../platform/utilities; ../../../../../../../../examples/usbkw40z_kw40z; ../../../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../../../examples/usbkw40z_kw40z; ../../../../../../../../platform/devices/MKW40Z4/startup; ../../../../../../../../platform/devices/MKW40Z4/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../lib/usbkw40z_kw40z.iar/release/mfs; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/nshell; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/config; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/mqx; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/mqx_stdlib
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/KW40Z4/release/libksdk_platform_mqx.a; ../../../../../lib/usbkw40z_kw40z.iar/release/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/usbkw40z_kw40z.iar/release/mqx_stdlib/lib_mqx_stdlib.a
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MKW40Z4/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/usbkw40z_kw40z/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h lite_config.h verif_enabled_config.h
  group Sources
    ../../../: Shell_Task.c Tasks.c
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group Debug Console
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.h print_scan.c
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group KSDK Files
    ../../../../../../../../examples/usbkw40z_kw40z/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
