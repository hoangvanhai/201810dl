<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>debug</name><member><project>mqx_frdmk64f</project><configuration>debug</configuration></member><member><project>mfs_frdmk64f</project><configuration>debug</configuration></member><member><project>nshell_frdmk64f</project><configuration>debug</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>debug</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Debug</configuration></member><member><project>ramdisk_frdmk64f</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>mqx_frdmk64f</project><configuration>release</configuration></member><member><project>mfs_frdmk64f</project><configuration>release</configuration></member><member><project>nshell_frdmk64f</project><configuration>release</configuration></member><member><project>mqx_stdlib_frdmk64f</project><configuration>release</configuration></member><member><project>ksdk_mqx_lib</project><configuration>Release</configuration></member><member><project>ramdisk_frdmk64f</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx\build\iar\mqx_frdmk64f\mqx_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\build\iar\mfs_frdmk64f\mfs_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\nshell\build\iar\nshell_frdmk64f\nshell_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\rtos\mqx\mqx_stdlib\build\iar\mqx_stdlib_frdmk64f\mqx_stdlib_frdmk64f.ewp</path></project><project><path>$WS_DIR$\..\..\..\..\..\..\..\..\lib\ksdk_mqx_lib\iar\K64F12\ksdk_mqx_lib.ewp</path></project><project><path>$WS_DIR$\ramdisk_frdmk64f.ewp</path></project></workspace>
