# IAR project ramdisk_frdmkv31f.ewp, settings and files
configuration int flash debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 Freescale MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MKV31F512VLL12=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MKV31F51212; ../../../../../../../../rtos/mqx/config/board/frdmkv31f; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../platform/utilities; ../../../../../../../../examples/frdmkv31f; ../../../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../../../examples/frdmkv31f; ../../../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../../../platform/devices/MKV31F51212/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../lib/frdmkv31f.iar/debug/mfs; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/debug/nshell; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/debug/config; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/debug/mqx; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/debug/mqx_stdlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../../../../rtos/mqx/config/mcu/MKV31F51212; ../../../../../../../../rtos/mqx/config/board/frdmkv31f; ../../../../../../../../examples/frdmkv31f; ../../../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../../../platform/devices/MKV31F51212/include
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: ramdisk.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x1
  ILINK.IlinkIcfFile: ../../../../../../../../platform/devices/MKV31F51212/linker/iar/MKV31F512xxx12_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/KV31F51212/debug/libksdk_platform_mqx.a; ../../../../../lib/frdmkv31f.iar/debug/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/debug/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/debug/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/debug/mqx_stdlib/lib_mqx_stdlib.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration int flash release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKV31F512VLL12=1; FSL_RTOS_MQX=1; PLATFORM_SDK_ENABLED=1; NDEBUG=1
  ICCARM.CCIncludePath2: ../../../../../../../../rtos/mqx/config/mcu/MKV31F51212; ../../../../../../../../rtos/mqx/config/board/frdmkv31f; ../../../../../../../../rtos/mqx/config/common; ../../..; ../../../../../../../../rtos/mqx/mqx/source/include; ../../../../../../../../rtos/mqx/mqx/source/bsp; ../../../../../../../../platform/utilities; ../../../../../../../../examples/frdmkv31f; ../../../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../../../examples/frdmkv31f; ../../../../../../../../platform/devices/MKV31F51212/startup; ../../../../../../../../platform/devices/MKV31F51212/include; ../../../../../../../../platform; ../../../../../../../../platform/devices; ../../../../../../../../platform/CMSIS/Include; ../../../../../../../../platform/hal/inc; ../../../../../../../../platform/drivers/inc; ../../../../../../../../platform/drivers/src/mpu; ../../../../../../../../platform/drivers/src/uart; ../../../../../../../../platform/utilities/inc; ../../../../../source/mfs_sdcard/nio_esdhc; ../../../../../../../../rtos; ../../../../../../../../platform/osa/inc; ../../../../../../../../platform/system/inc; ../../../../../lib/frdmkv31f.iar/release/mfs; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/release/nshell; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/release/config; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/release/mqx; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/release/mqx_stdlib
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/ksdk_mqx_lib/iar/KV31F51212/release/libksdk_platform_mqx.a; ../../../../../lib/frdmkv31f.iar/release/mfs/lib_mfs.a; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/release/nshell/lib_nshell.a; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/release/mqx/lib_mqx.a; ../../../../../../../../rtos/mqx/lib/frdmkv31f.iar/release/mqx_stdlib/lib_mqx_stdlib.a
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MKV31F51212/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/frdmkv31f/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h lite_config.h verif_enabled_config.h
  group Sources
    ../../../: Shell_Task.c Tasks.c
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group Debug Console
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.h print_scan.c
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group KSDK Files
    ../../../../../../../../examples/frdmkv31f/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
