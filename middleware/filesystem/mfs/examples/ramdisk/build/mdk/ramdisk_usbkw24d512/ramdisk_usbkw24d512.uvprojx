# Keil uVision project ramdisk_usbkw24d512.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MKW24D512VHA5 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4")
  output: ramdisk.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKW24D512VHA5=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, _DEBUG=1
  c misc: -J../../../../../../../../rtos/mqx/config/mcu/MKW24D5 
-J../../../../../../../../rtos/mqx/config/board/usbkw24d512 
-J../../../../../../../../rtos/mqx/config/common 
-J../../.. 
-J../../../../../../../../rtos/mqx/mqx/source/include 
-J../../../../../../../../rtos/mqx/mqx/source/bsp 
-J../../../../../../../../platform/utilities 
-J../../../../../../../../examples/usbkw24d512 
-J../../../../../../../../platform/devices/MKW24D5/startup 
-J../../../../../../../../examples/usbkw24d512 
-J../../../../../../../../platform/devices/MKW24D5/startup 
-J../../../../../../../../platform/devices/MKW24D5/include 
-J../../../../../../../../platform 
-J../../../../../../../../platform/devices 
-J../../../../../../../../platform/CMSIS/Include 
-J../../../../../../../../platform/hal/inc 
-J../../../../../../../../platform/drivers/inc 
-J../../../../../../../../platform/drivers/src/mpu 
-J../../../../../../../../platform/drivers/src/uart 
-J../../../../../../../../platform/utilities/inc 
-J../../../../../source/mfs_sdcard/nio_esdhc 
-J../../../../../../../../rtos 
-J../../../../../../../../platform/osa/inc 
-J../../../../../../../../platform/system/inc 
-J../../../../../lib/usbkw24d512.mdk/debug/mfs 
-J../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/nshell 
-J../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/config 
-J../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/mqx 
-J../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/mqx_stdlib 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../../../rtos/mqx/config/mcu/MKW24D5;../../../../../../../../rtos/mqx/config/board/usbkw24d512;../../../../../../../../rtos/mqx/config/common;../../..;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../platform/utilities;../../../../../../../../examples/usbkw24d512;../../../../../../../../platform/devices/MKW24D5/startup;../../../../../../../../examples/usbkw24d512;../../../../../../../../platform/devices/MKW24D5/startup;../../../../../../../../platform/devices/MKW24D5/include;../../../../../../../../platform;../../../../../../../../platform/devices;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/utilities/inc;../../../../../source/mfs_sdcard/nio_esdhc;../../../../../../../../rtos;../../../../../../../../platform/osa/inc;../../../../../../../../platform/system/inc;../../../../../lib/usbkw24d512.mdk/debug/mfs;../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/nshell;../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/config;../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/mqx;../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/mqx_stdlib
  asm misc: --cpreproc_opts '-DCPU_MKW24D512VHA5=1,-DFSL_RTOS_MQX=1,-DPLATFORM_SDK_ENABLED=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../../../rtos/mqx/config/mcu/MKW24D5;../../../../../../../../rtos/mqx/config/board/usbkw24d512;../../../../../../../../examples/usbkw24d512;../../../../../../../../platform/devices/MKW24D5/startup;../../../../../../../../platform/devices/MKW24D5/include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ../../../../../../../../platform/devices/MKW24D5/linker/arm/MKW24D512xxx5_flash.scf
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/KW24D5/debug/libksdk_platform_mqx.lib 
../../../../../lib/usbkw24d512.mdk/debug/mfs/lib_mfs.lib 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/nshell/lib_nshell.lib 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--autoat 
--any_placement=first_fit 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MKW24D5/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/usbkw24d512/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h lite_config.h verif_enabled_config.h
  group Sources
    ../../../: Shell_Task.c Tasks.c
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group Debug Console
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.h print_scan.c
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group KSDK Files
    ../../../../../../../../examples/usbkw24d512/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
target int flash release (ARM-ADS)
  device: MKW24D512VHA5 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4")
  output: ramdisk.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKW24D512VHA5=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, NDEBUG=1
  c misc: -J../../../../../../../../rtos/mqx/config/mcu/MKW24D5 
-J../../../../../../../../rtos/mqx/config/board/usbkw24d512 
-J../../../../../../../../rtos/mqx/config/common 
-J../../.. 
-J../../../../../../../../rtos/mqx/mqx/source/include 
-J../../../../../../../../rtos/mqx/mqx/source/bsp 
-J../../../../../../../../platform/utilities 
-J../../../../../../../../examples/usbkw24d512 
-J../../../../../../../../platform/devices/MKW24D5/startup 
-J../../../../../../../../examples/usbkw24d512 
-J../../../../../../../../platform/devices/MKW24D5/startup 
-J../../../../../../../../platform/devices/MKW24D5/include 
-J../../../../../../../../platform 
-J../../../../../../../../platform/devices 
-J../../../../../../../../platform/CMSIS/Include 
-J../../../../../../../../platform/hal/inc 
-J../../../../../../../../platform/drivers/inc 
-J../../../../../../../../platform/drivers/src/mpu 
-J../../../../../../../../platform/drivers/src/uart 
-J../../../../../../../../platform/utilities/inc 
-J../../../../../source/mfs_sdcard/nio_esdhc 
-J../../../../../../../../rtos 
-J../../../../../../../../platform/osa/inc 
-J../../../../../../../../platform/system/inc 
-J../../../../../lib/usbkw24d512.mdk/release/mfs 
-J../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/nshell 
-J../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/config 
-J../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/mqx 
-J../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/mqx_stdlib 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../../../rtos/mqx/config/mcu/MKW24D5;../../../../../../../../rtos/mqx/config/board/usbkw24d512;../../../../../../../../rtos/mqx/config/common;../../..;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../platform/utilities;../../../../../../../../examples/usbkw24d512;../../../../../../../../platform/devices/MKW24D5/startup;../../../../../../../../examples/usbkw24d512;../../../../../../../../platform/devices/MKW24D5/startup;../../../../../../../../platform/devices/MKW24D5/include;../../../../../../../../platform;../../../../../../../../platform/devices;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/utilities/inc;../../../../../source/mfs_sdcard/nio_esdhc;../../../../../../../../rtos;../../../../../../../../platform/osa/inc;../../../../../../../../platform/system/inc;../../../../../lib/usbkw24d512.mdk/release/mfs;../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/nshell;../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/config;../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/mqx;../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/mqx_stdlib
  asm misc: --cpreproc_opts '-DCPU_MKW24D512VHA5=1,-DFSL_RTOS_MQX=1,-DPLATFORM_SDK_ENABLED=1,-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: as above
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/KW24D5/release/libksdk_platform_mqx.lib 
../../../../../lib/usbkw24d512.mdk/release/mfs/lib_mfs.lib 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/nshell/lib_nshell.lib 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/usbkw24d512.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--autoat 
--any_placement=first_fit 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
