<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\..\..\..\..\..\rtos\mqx\mqx\build\mdk\mqx_frdmkw40z\mqx_frdmkw40z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\build\mdk\mfs_frdmkw40z\mfs_frdmkw40z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\..\..\rtos\mqx\nshell\build\mdk\nshell_frdmkw40z\nshell_frdmkw40z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\..\..\rtos\mqx\mqx_stdlib\build\mdk\mqx_stdlib_frdmkw40z\mqx_stdlib_frdmkw40z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\..\..\..\..\..\lib\ksdk_mqx_lib\mdk\KW40Z4\ksdk_mqx_lib.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>ramdisk_frdmkw40z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
